# Keil uVision project Odev1_1_2017010225048.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC842 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(32768) DPX MODAB2
  output: Odev1_1_2017010225048
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: dac_sin_12.a51
