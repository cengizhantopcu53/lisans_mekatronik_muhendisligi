# Keil uVision project 2021_final.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC842 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(32768) DPX MODAB2
  output: 2021_final
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: soru1.a51 soru2.a51 soru3.a51 soru4.a51 soru5.a51
